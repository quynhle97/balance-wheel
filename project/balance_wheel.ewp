# IAR project balance_wheel.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103F3P6
  ICCSTM8.CCIncludePath2: E:\stm8\balance_wheel\libraries\inc; E:\stm8\balance_wheel\user
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: balance_wheel.hex
  ILINK.IlinkOutputFile: balance_wheel.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group libraries
    ../libraries/src/: stm8s_clk.c stm8s_gpio.c stm8s_i2c.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c
  group user
    ../user/: main.c main.h newTimer.c stm8s_conf.h stm8s_it.c stm8s_it.h
