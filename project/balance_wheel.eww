<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\balance_wheel.ewp</path>
  </project>
  <batchBuild/>
</workspace>


